# Keil uVision project GUI_targetCryoController.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GUI_targetCryoController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\App_Layer;.\lib\Func_Layer;.\lib\HW_Layer
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App_Layer
    ./lib/App_Layer/: GUI_cryoTargetController.c GUI_cryoTargetController.h main.c
  group Func_Layer
    ./lib/Func_Layer/: Font.h GUI.c GUI.h link.h
  group HW_Layer
    ./lib/HW_Layer/: CPU.c CPU.h I2C.c I2C.h LCD_ILI9341.c LCD_ILI9341.h SPI.c SPI.h Timer.c Timer.h Touch_FT6236.c Touch_FT6236.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.5
